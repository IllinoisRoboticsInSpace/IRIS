Commit message: tilted the camera

File: sam_bot_description/src/description/sam_bot_description_tutorial.urdf (robot description, URDF)
Before this commit: robot sam_bot, 6 links, 5 joints
Joints:
- joint camera_joint: origin xyz=0.215 0 0.05 rpy=0 0 0 -> xyz=0.215 0 0.07 rpy=0 ${pi/8} 0
